options:
  parameters:
    author: spacecraft
    generate_options: qt_gui
    id: testTransmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth_time
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '55555'
  states: {}
- name: dev
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: frame_length
  id: variable
  parameters:
    value: '0x40'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '459200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_sym * baud_rate
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/spacecraft/mdrMATLAB/iqSamplesRecent.bin
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/spacecraft/mdrMATLAB/iqSamplesRecent2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/spacecraft/mdrMATLAB/tT.bin
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52010'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"mod_packet_len"'
    packet_len: 1036*8
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: burst_preamble_insert_0
  id: burst_preamble_insert
  parameters:
    preamble: '0x8ad8bb2a'
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '8'
    mask: '0x221'
    reset_tag_key: '"packet_len"'
    seed: '0x1ff'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    alias: burst_shaper1
    insert_phasing: 'True'
    length_tag_name: mod_packet_len
    post_padding: '10'
    pre_padding: '10'
    type: complex
    window: firdes.window(firdes.WIN_HANN, 50, 0)
  states: {}
- name: digital_gfsk_mod_1
  id: digital_gfsk_mod
  parameters:
    bt: '.5'
    samples_per_symbol: '8'
    sensitivity: '1.5'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: sdlp_create_frame_0
  id: sdlp_create_frame
  parameters:
    TF_version: '1'
    bypass_flag: '0'
    control_command_flag: '0'
    fecf: '0'
    ocf: '0'
    scid: '47'
    vcid: '31'
  states: {}
- name: spp_create_packet_0
  id: spp_create_packet
  parameters:
    apid: '2002'
    enckey: loremipsumdolore
    encrypt: '1'
    packetType: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '459200000'
    dev_args: '""'
    gain0: '90'
    len_tag_name: mod_packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_packed_to_unpacked_xx_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_2, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gfsk_mod_1, '0']
- [blocks_socket_pdu_0, pdus, spp_create_packet_0, in]
- [blocks_stream_to_tagged_stream_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, burst_preamble_insert_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [burst_preamble_insert_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digital_additive_scrambler_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_file_sink_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [digital_burst_shaper_xx_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [sdlp_create_frame_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [spp_create_packet_0, out, sdlp_create_frame_0, in]
- [uhd_usrp_source_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1

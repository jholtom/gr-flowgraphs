options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth_time
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '55652'
  states: {}
- name: dev
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: frame_length
  id: variable
  parameters:
    value: '0x40'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '459200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_sym*baud_rate
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: variable_ccsds_encoder_def_0
  id: variable_ccsds_encoder_def
  parameters:
    framebits: '2048'
    mode: fec.CC_STREAMING
    ndim: '0'
    state_start: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/bfrancis/txotest.bin
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello to BYU from Space")
    period: '1000'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: packet_len
    post_padding: '10'
    pre_padding: '10'
    type: complex
    window: numpy.ones(50)
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: samp_sym
    sensitivity: sensitivity
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdlp_create_frame_0_0
  id: sdlp_create_frame
  parameters:
    TF_version: '1'
    bypass_flag: '0'
    control_command_flag: '0'
    fecf: '0'
    ocf: '0'
    scid: '47'
    vcid: '31'
  states: {}
- name: spp_create_packet_0_0
  id: spp_create_packet
  parameters:
    apid: '2002'
    enckey: abcdefghijklmnop
    encrypt: '0'
    packetType: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '60'
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, spp_create_packet_0_0, in]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [digital_burst_shaper_xx_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [sdlp_create_frame_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [spp_create_packet_0_0, out, sdlp_create_frame_0_0, in]

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: A_beacons
  id: variable
  parameters:
    value: '5813'
  states: {}
- name: A_beacons_0
  id: variable
  parameters:
    value: '5813'
  states: {}
- name: A_out
  id: variable
  parameters:
    value: '5800'
  states: {}
- name: A_out_apid
  id: variable
  parameters:
    value: '5800'
  states: {}
- name: A_rx_freq
  id: variable
  parameters:
    value: '903789000'
  states: {}
- name: A_tftp_in
  id: variable
  parameters:
    value: '"51014"'
  states: {}
- name: A_tftp_in_0
  id: variable
  parameters:
    value: '51014'
  states: {}
- name: A_tftp_out
  id: variable
  parameters:
    value: '5814'
  states: {}
- name: A_tftp_out_0
  id: variable
  parameters:
    value: '5814'
  states: {}
- name: A_tx_freq
  id: variable
  parameters:
    value: '459193000'
  states: {}
- name: B_beacons
  id: variable
  parameters:
    value: '5913'
  states: {}
- name: B_beacons_0
  id: variable
  parameters:
    value: '5913'
  states: {}
- name: B_out
  id: variable
  parameters:
    value: '5900'
  states: {}
- name: B_out_0
  id: variable
  parameters:
    value: '5900'
  states: {}
- name: B_rx_freq
  id: variable
  parameters:
    value: '903400000'
  states: {}
- name: B_tftp_in
  id: variable
  parameters:
    value: '"51114"'
  states: {}
- name: B_tftp_in_0
  id: variable
  parameters:
    value: '51114'
  states: {}
- name: B_tftp_out
  id: variable
  parameters:
    value: '5914'
  states: {}
- name: B_tftp_out_0
  id: variable
  parameters:
    value: '5914'
  states: {}
- name: B_tx_freq
  id: variable
  parameters:
    value: '459000000'
  states: {}
- name: bandwidth_time
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: frame_length
  id: variable
  parameters:
    value: '2040'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rx_baud_rate
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: rx_baud_rate * samp_sym
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: '1.5'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: tx_baud_rate
  id: variable
  parameters:
    value: '55652'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: samp_sym*tx_baud_rate
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '100'
    threshold: '-70'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: A_rx_freq - actual_freq
    offset: '0'
    phase: '0'
    samp_rate: rx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: rx_baud_rate/1.5
    low_cutoff_freq: '-rx_baud_rate/1.5'
    samp_rate: rx_samp_rate
    type: fir_filter_ccc
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/spacecraft/mdrMATLAB/iqSamples.bin
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5813'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '51014'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5814'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5830'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"mod_packet_len"'
    packet_len: 1036*8
    type: complex
  states: {}
- name: burst_preamble_insert_0
  id: burst_preamble_insert
  parameters:
    preamble: '0x8ad8bb2a'
  states: {}
- name: ccsds_reed_solomon_0
  id: ccsds_reed_solomon
  parameters: {}
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '8'
    mask: '0x221'
    reset_tag_key: '"frame_len"'
    seed: '0x1ff'
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: mod_packet_len
    post_padding: '10'
    pre_padding: '10'
    type: complex
    window: firdes.window(firdes.WIN_HANN, 50,0)
  states: {}
- name: digital_gfsk_mod_1
  id: digital_gfsk_mod
  parameters:
    bt: bandwidth_time
    samples_per_symbol: samp_sym
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import scipy.signal


      class blk(gr.basic_block):
          """GMSK Packet Decoder
          
          Looks for tags from power squelch to know where packets start and end.
          """
          _out_port = pmt.intern("out")
          packetNum = 1
          packet = []
          packetStarted = False


          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='mdr GMSK Packet Demod',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.message_port_register_out(self._out_port)
          
          def mdrBitSync(self,y):
              N1 = 8
              g = np.multiply(1/N1,np.ones((N1,1)))
              Kp = 8.7
              N2 = 2
              K0 = -1
          
              BnT = 0.02
              zeta = 1
              temp = BnT/(zeta + 0.25/zeta)
              d = 1 + 2*zeta/N2 * temp + (temp/N2)**2
              K1 = 4*zeta/N2 * temp / d
              K2 = (2/N2 * temp)**2 / d
              K1 = K1/(K0*Kp)
              K2 = K2/(K0*Kp)

              b0 = (K1 + K2)
              b1 = -K1

              # apply matched filter and downsample to 2 samples/bit
              xx = scipy.signal.decimate(y,4);
          
              # create output vector
              b = np.zeros(int(0.52*len(xx)))
              k = 0
          
              # initialize PLL states
              NCO1 = 0
              W1 = 0
              Vt1 = 0
              Et1 = 0
              MU1 = 0
          
              F1 = 0
              F2 = 0
              F3 = 0
              F4 = 0
              F5 = 0
              F6 = 0
              F7 = 0
              F8 = 0
              F9 = 0
              
              for idx in range(len(xx)):
                  # check for underflow
                  # if underflow, strobe = 1 compute new mu
                  
                  temp = NCO1 - W1
                  if temp < 0:
                      strobe = 1
                      mu = NCO1/W1
                      nco = 1 + temp
                  else:
                      strobe = 0
                      mu = MU1
                      nco = temp
                  
                  # if strobe, compute timing error and produce output
              
                  if strobe == 0:
                      et = 0
                  else:
                      # calculate xi(idx)
                      tempFx = -0.5*xx[idx]
                      v2 = -tempFx + F1 + F2 - F3
                      v1 = tempFx - F1 + F6 + F2 + F3
                      v0 = F7
                      xi = (v2 * mu + v1) * mu + v0
                  
                      # calculate xi(idx-1)
                      v2 = -F1 + F2 + F3 - F4
                      v1 = F1 - F2 + F7 + F3 + F4
                      v0 = F8
                      xi1 = (v2 * mu + v1) * mu + v0
              
                      # calculate xi(idx-2)
                      v2 = -F2 + F3 + F4 - F5
                      v1 = F2 - F3 + F8 + F4 + F5
                      v0 = F9
                      xi2 = (v2 * mu + v1) * mu + v0
              
                      et = np.sign(xi1) * (xi - xi2)
                
                      b[k] = (xi1 > 0)
                      k = k + 1      
                  
                  # update loop filter output
              
                  vt = Vt1 + b0*et + b1*Et1
              
                  # update NCO input
              
                  w = vt + 0.5
              
                  # update states
              
                  F5 = F4
                  F4 = F3
                  F3 = F2
                  F2 = F1
                  F1 = -0.5*xx[idx]
                  F9 = F8
                  F8 = F7
                  F7 = F6
                  F6 = xx[idx]
              
                  Et1 = et
                  Vt1 = vt
              
                  NCO1 = nco
                  MU1 = mu
                  W1 = w
              
              b = np.uint8(b[0:k-1])
              packet = pmt.init_u8vector(len(b),b.tolist())
              out_packet = pmt.cons(pmt.to_pmt(None),packet)
              self.message_port_pub(self._out_port,out_packet)
          
          def mdrDemod(self):
              x = np.array(self.packet)
              self.packet.clear()
              if len(x) < 100000:
                  return
              d = np.array([1,0,-1])
              dx = np.convolve(d,x)
              y = np.float32(np.imag(np.conj(x)*dx[1:len(dx)-1]) / np.square(np.absolute(x)))
              self.mdrBitSync(y)
          
          def checkSob(self,offset,in_data):
              tags = self.get_tags_in_window(0, offset, len(in_data),pmt.intern('squelch_sob'))
              if len(tags) != 0:
                  relIdx = tags[0].offset - self.nitems_read(0)
                  self.packetStarted = True
                  self.checkEob(relIdx,in_data)

          def checkEob(self,offset,in_data):
              tags = self.get_tags_in_window(0, offset, len(in_data),pmt.intern('squelch_eob'))
              if len(tags) == 0:
                  self.packet.extend(in_data[offset:len(in_data)])
              else:
                  relIdx = tags[0].offset - self.nitems_read(0)
                  self.packet.extend(in_data[offset:relIdx])
                  if len(self.packet) > 125000:
                      self.mdrDemod()
                      self.packetNum += 1
                  else:
                      self.packet.clear()
                  self.packetStarted = False
                  self.checkSob(relIdx+1,in_data)

          def general_work(self, input_items, output_items):
               in_data = input_items[0]
               
               if self.packetStarted:
                   self.checkEob(0,in_data)
               else:
                   self.checkSob(0,in_data)
               
               self.consume(0, len(in_data))
               
               return len(input_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from pmt import *
      from pmt import pmt_to_python

      def str_to_bits(data):
          out_data = list()
          for i in range(len(data)):
              out_data.append(int(data[i]))
          return out_data

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          _in_port = pmt.intern("in")
          _out_port = pmt.intern("out")

          def __init__(self, frame_size=2040, access_code='00011010110011111111110000011011', threshold=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Detect Packet',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.frame_size = frame_size
              self.access_code = str_to_bits(access_code)
              self.threshold = threshold
              
              self.message_port_register_in(self._in_port) #this creates the input port for the messages
              self.set_msg_handler(self._in_port, self.msg_handler_method) #this determines what is done with any recieved messages as soon as they are recieved
              self.message_port_register_out(self._out_port) #this creates the output port for messages
              
          def find_access_code(self):
              ac_len = len(self.access_code)
              found = False
              i = 0
              while len(self.data[i:]) >= ac_len:
                  wrong = 0
                  j = 0
                  while wrong < self.threshold:
                      if self.data[i+j] != self.access_code[j]:
                          wrong += 1
                      j += 1
                      if j == ac_len:
                          print("Detect Packet: Found access code, extracting packet")
                          self.extract_packet(i+ac_len)
                          return
                  i += 1
                      
          def extract_packet(self, idx):
              self.packet.clear()
              if len(self.data[idx:])/8 < self.frame_size:
                  print("Detect Packet: Not enough data for frame size")
              for i in range(self.frame_size):
                  sum = 0
                  for j in range(8):
                      sum += self.data[idx+8*i+j] << (7-j)
                  self.packet.append(sum)
              
          def msg_handler_method(self, msg):
              if pmt.is_symbol(msg):
                  msg_str = str(pmt.symbol_to_string(msg)) #changes the data back into usable data
                  self.data = msg_str
              elif pmt.is_pair(msg):
                  incoming_dict = pmt.car(msg)
                  incoming_data = pmt.cdr(msg)
                  self.data = pmt.to_python(incoming_data).tobytes()
                  self.packet = list()
                  self.find_access_code()
                  if len(self.packet) > 0:
                      out_msg = pmt.init_u8vector(len(self.packet), self.packet)
                      deliver_msg = pmt.cons(pmt.to_pmt(None), out_msg)
                      self.message_port_pub(self._out_port, deliver_msg)

          def general_work(self, input_items, output_items):
              print("Detect Packet: general_work called?")
              return len(output_items[0])
    access_code: '''00011010110011111111110000011101'''
    frame_size: frame_length
    threshold: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"black"'
    grid: 'True'
    gui_hint: tab@2
    marker1: '8'
    size: '1024'
    style1: '1'
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: rx_samp_rate
    ctrlpanel: 'True'
    fc: A_rx_freq
    fftsize: '1024'
    gui_hint: tab@3
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rx_samp_rate
    fc: A_rx_freq
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rx_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdlp_create_frame_0
  id: sdlp_create_frame
  parameters:
    TF_version: '1'
    bypass_flag: '0'
    control_command_flag: '0'
    fecf: '0'
    ocf: '0'
    scid: '47'
    vcid: '31'
  states: {}
- name: sdlp_destruct_frame_0
  id: sdlp_destruct_frame
  parameters: {}
  states: {}
- name: spp_create_packet_0
  id: spp_create_packet
  parameters:
    apid: '1014'
    enckey: loremipsumdolore
    encrypt: '1'
    packetType: '1'
  states: {}
- name: spp_destruct_packet_0
  id: spp_destruct_packet
  parameters:
    beaconapid: '813'
    elysiumapid: '830'
    enckey: loremipsumdolore
    encrypt: '1'
    sf2cmdapid: '811'
    tftpapid: '814'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: USRP
    label1: Squelch
    label2: Constellation
    label3: FFT
    num_tabs: '4'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: tx_samp_rate
    center_freq0: A_tx_freq
    dev_args: '""'
    gain0: '65'
    len_tag_name: mod_packet_len
    norm_gain0: 'False'
    samp_rate: tx_samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: rx_samp_rate
    center_freq0: A_rx_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: rx_samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', band_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', epy_block_0, '0']
- [band_pass_filter_0, '0', qtgui_const_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_multiply_xx_1, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_1, '0', digital_gfsk_mod_1, '0']
- [blocks_socket_pdu_0_0, pdus, spp_create_packet_0, in]
- [blocks_stream_to_tagged_stream_0, '0', digital_burst_shaper_xx_0, '0']
- [burst_preamble_insert_0, out, blocks_pdu_to_tagged_stream_0_0_1, pdus]
- [ccsds_reed_solomon_0, out, sdlp_destruct_frame_0, in]
- [digital_burst_shaper_xx_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_gfsk_mod_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0, out, epy_block_1, in]
- [epy_block_1, out, ccsds_reed_solomon_0, in]
- [sdlp_create_frame_0, out, burst_preamble_insert_0, in]
- [sdlp_destruct_frame_0, out, spp_destruct_packet_0, in]
- [spp_create_packet_0, out, sdlp_create_frame_0, in]
- [spp_destruct_packet_0, beacon, blocks_socket_pdu_0, pdus]
- [spp_destruct_packet_0, elysium, blocks_socket_pdu_1_0, pdus]
- [spp_destruct_packet_0, out, blocks_socket_pdu_1_0, pdus]
- [spp_destruct_packet_0, sf2cmd, blocks_socket_pdu_1_0, pdus]
- [spp_destruct_packet_0, tftp, blocks_socket_pdu_1, pdus]
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
